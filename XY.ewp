# IAR project XY.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCIncludePath2: ; Libraries\inc; USB_Lib\inc; Libraries\CMSIS; TFT; fatfs; User; ADC; PWM; HAL
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: XY.bin
  ILINK.IlinkOutputFile: XY.out
  ILINK.IlinkIcfFile: C:\Users\Administrator\Desktop\XY_V1.0.0.1\XY_V1.0.0.1\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group ADC
    ADC/: Stm32_ADC.c
  group CMSIS
    Libraries/CMSIS/: core_cm3.c
    User/: system_stm32f10x.c
  group FWLib
    Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group HAL
    HAL/: 25f.c touch.c
  group PWM
    PWM/: Stm_Pwm.c
  group STARTUP
    startup/iar/: startup_stm32f10x_md.s
  group TFT
    TFT/BMP/: bmp_data.c
    TFT/: BUTTON.c check.c combo.c DX_gui.c DX_Touch.c EDIT.c font_data.c GuiData.c Mem.c progress.c TFTdriver.c TFTHAL.c usr.c widget.c window.c
  group User
    User/: hal.c main.c RCC_config.c RTC.c stm32f10x_it.c usart.c
